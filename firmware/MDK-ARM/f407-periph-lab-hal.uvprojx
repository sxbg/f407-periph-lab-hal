# Keil uVision project f407-periph-lab-hal.uvprojx, settings and files
target f407-periph-lab-hal (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407-periph-lab-hal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../App/app;../App/domain;../App/ports;../App/adapters;../App/platform;../App/config;../Middlewares/SEGGER/RTT;../App/bsp;../App/shell;..\App\app;..\App\domain;..\App\ports;..\App\adapters;..\App\platform;..\App\config;..\App\bsp;..\App\shell
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c crc.c dac.c dma.c i2c.c iwdg.c rng.c rtc.c sdio.c spi.c tim.c usart.c wwdg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App/app
    ../App/app/: app_main.c
  group App/domain
    ../App/domain/: blink_state.c
  group App/adapters
    ../App/adapters/: adapters.c
  group App/platform
    ../App/platform/: boot_diag.c fault_capture.c log_uart.c rtt_log.c fault_trampoline.s
  group RTT
    ../Middlewares/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group App/shell
    ../App/shell/: test_menu.c
  group App/bsp
    ../App/bsp/: bsp_adc.c bsp_can_loopback.c bsp_crc_rng.c bsp_dac.c bsp_dma.c bsp_exti.c bsp_flash_iap.c bsp_gpio.c bsp_i2c_eeprom.c bsp_oled.c bsp_pwr.c bsp_rtc.c bsp_sdio_tf.c bsp_spi_flash.c bsp_tim_adv.c bsp_tim_basic.c bsp_tim_encoder.c bsp_tim_ic.c bsp_tim_pwm.c bsp_uart.c bsp_wdg.c i2c_soft_bus.c
software components: CMSIS:CORE 4.3.0
